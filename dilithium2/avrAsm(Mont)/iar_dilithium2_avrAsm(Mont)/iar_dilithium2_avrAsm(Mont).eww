<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\iar_dilithium2_avrAsm(Mont).ewp</path>
    </project>
    <batchBuild />
</workspace>
