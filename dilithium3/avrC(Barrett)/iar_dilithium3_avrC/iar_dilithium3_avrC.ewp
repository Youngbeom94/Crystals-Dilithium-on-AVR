# IAR project iar_dilithium3_avrC.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.RTConfigPath: DLib_Config_Normal.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: 6 -v6, Max 16 Mbyte data, 8 Mbyte code
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 2
  ICCAVR.CCOptLevel: 3
  XLINK.XclFile: $TOOLKIT_DIR$/src/template/lnk6s.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.GenDeviceSelectMenu: 3
  ICCAVR.CCDefines: NDEBUG
  ICCAVR.CCOptStrategy: 1
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ../: api.h barrett_arithmetic.c barrett_arithmetic.h fips202.c fips202.h fnt769.c fnt769.h main.c ntt.c ntt.h NTT_params.h packing.c packing.h params.h poly.c poly.h polyvec.c polyvec.h randombytes.c randombytes.h reduce.c reduce.h rounding.c rounding.h sign.c sign.h symmetric-shake.c symmetric.h
